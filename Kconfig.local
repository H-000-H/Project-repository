## sdkconfig.defaults
```kconfig
CONFIG_SYSTEM_CMD=y
CONFIG_LV_FONT_MONTSERRAT_12=y
CONFIG_LV_FONT_MONTSERRAT_16=y
```
